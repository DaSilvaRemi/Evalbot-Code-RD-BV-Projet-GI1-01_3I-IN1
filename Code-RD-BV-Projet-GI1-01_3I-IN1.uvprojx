# Keil uVision project Code-RD-BV-Projet-GI1-01_3I-IN1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Code-RD-BV-Projet-GI1-01_3I-IN1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: RD_BV_CONFIG_LED.s RD_BV_CONFIG_SWITCH.s RD_BV_MAIN.s RD_BV_CONFIG_BUMPER.s RD_BV_WAIT.S RD_BV_CONFIG_ENGINE.s
software components: CMSIS:CORE 5.2.0, Device:Startup 1.1.0
